# Keil uVision project empty.uvprojx, settings and files
target empty (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MSP432P401R Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IROM(0x00000000,0x00040000) IROM2(0x00200000,0x00004000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: empty
  AfterMake: fromelf --bin --output .\Build\empty.bin .\Build\empty.axf
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __MSP432P401R__
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\hardware;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include;..\SYSTEM
  asm include: ..\keil;..\keil;..\..\ti_driverlib\simplelink_msp432p4_sdk_3_40_01_02\third_party\CMSIS\Include;..\hardware;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1000000 size 0x10000
  group Source
    ../: main.c system_msp432p401r.c
    ./: startup_msp432p401r_uvision.s
  group Library
    ../../ti_driverlib/simplelink_msp432p4_sdk_3_40_01_02/ti/devices/msp432p4xx/driverlib/keil/: msp432p4xx_driverlib.lib
  group Hardware
    ../hardware/: led.c key.c oled.c bsp_mpu6050.c
    ../SYSTEM/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group sys
    ../SYSTEM/: usart.h usart.c sysinit.h sysinit.c baudarte.h baudarte.c delay.h delay.c
software components: CMSIS:CORE 4.3.0
